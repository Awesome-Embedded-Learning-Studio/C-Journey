# Keil uVision project 2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group LED_Matrix
    ./: STARTUP.A51 LEDMat.c LEDMat.h
  group Delay
    ../1/: delay.c delay.h
  group Main
    ./: main.c
  group Obtacle
    ./: obtacle.c obtacle.h
  group Configure
    ./: Utilitys.h
  group Key Controller
    ./: key.c key.h KeyEvent.c KeyEvent.h
  group Player
    ./: player.h Player.c
  group GUI
    ./: GUI.c GUI.h
  group DiditalLED
    ./: DigitalLED.c lcd1602.c lcd1602.h DigitalLED.h
  group Beep
    ./: Beep.c Beep.h
  group GameRelated
    ./: defaultAct.c defaultAct.h
  group ControlOnComputer
    ./: UART.c UART.h
  group MatrixKey
    ./: MatKey.c MatKey.h
