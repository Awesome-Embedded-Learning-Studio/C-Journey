# Keil uVision project LEDMatrix.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LEDMatrix +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 MatrixLED.c MatrixLEd.h Delay.c Delay.h main.c Key.c Key.h
