# Keil uVision project Timer.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Timer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c lcd1602.c lcd1602.h Timer0.c Timer0.h Key.h Key.c Delay.c Delay.h showTime.c showTime.h
